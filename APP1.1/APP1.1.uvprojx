# Keil uVision project APP1.1.uvprojx, settings and files
target APP1.1 (5060960::V5.06 update 7 (build 960)::.\ARMCC)
  device: STM32F103C8 STMicroelectronics
  pack: Keil.STM32F1xx_DFP.2.4.1
  cpu: IRAM(0x20000000,0x5000) IROM(0x08005000,0xB000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: project +hex
  AfterMake: fromelf.exe --bin --output ".\Objects\project.bin" ".\Objects\project.axf"
  c flags: Optim=2 OneElfS=1 uC99=1 v6Lang=3 v6LangP=3 wLevel=2
  c define: USE_STDPERIPH_DRIVER
  c include: .\User;..\APP1.0\Start;..\APP1.0\Library;.\BSP;.\BSP\Inc
  memory RVCT4: ROM 0x8005000 size 0x10000
  memory RVCT9: RAM 0x20000000 size 0x5000
  group Start
    ../APP1.0/Start/: startup_stm32f10x_md.s core_cm3.c core_cm3.h stm32f10x.h system_stm32f10x.c system_stm32f10x.h
  group Library
    ../APP1.0/Library/: misc.c misc.h stm32f10x_gpio.c stm32f10x_gpio.h stm32f10x_rcc.c stm32f10x_rcc.h stm32f10x_tim.c stm32f10x_tim.h
  group BSP
    ./BSP/Src/: bsp.c bsp_gpio.c
  group User
    ./User/: main.c delay.c stm32f10x_conf.h stm32f10x_it.c stm32f10x_it.h
